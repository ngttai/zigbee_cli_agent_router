# IAR project zigbee_cli_agent_router_pca10059_mbr.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10059; CONFIG_GPIO_AS_PINRESET; ENABLE_FEM; FLOAT_ABI_HARD; MBR_PRESENT; NRF52840_XXAA; ZB_TRACE_LEVEL=0; ZB_TRACE_MASK=0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\..\components\libraries\cli; ..\..\..\..\..\..\..\..\components\libraries\cli\cdc_acm; ..\..\..\..\..\..\..\..\components\libraries\cli\rtt; ..\..\..\..\..\..\..\..\components\libraries\cli\uart; ..\..\..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\..\components\libraries\usbd; ..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc; ..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm; ..\..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\..\components\softdevice\mbr\headers; ..\..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\..\..\components\zigbee\cli; ..\..\..\..\..\..\..\..\components\zigbee\common; ..\..\..; ..\..\..\..\..\..\..\..\external\fnmatch; ..\..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src; ..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem; ..\..\..\..\..\..\..\..\external\nRF-IEEE-802.15.4-radio-driver\src\fem\three_pin_gpio; ..\..\..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\..\..\external\utf_converter; ..\..\..\..\..\..\..\..\external\zboss\addons; ..\..\..\..\..\..\..\..\external\zboss\include; ..\..\..\..\..\..\..\..\external\zboss\include\ha; ..\..\..\..\..\..\..\..\external\zboss\include\osif; ..\..\..\..\..\..\..\..\external\zboss\include\zcl; ..\..\..\..\..\..\..\..\external\zboss\osif; ..\..\..\..\..\..\..\..\external\zboss\zb_error; ..\..\..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: zigbee_cli_agent_router_pca10059_mbr.hex
  ILINK.IlinkOutputFile: zigbee_cli_agent_router_pca10059_mbr.out
  ILINK.IlinkIcfFile: zigbee_cli_agent_router_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../../../components/boards/: boards.c
  group Zigbee
    ../../../../../../../../external/zboss/lib/iar/: libzboss.a
    ../../../../../../../../external/zboss/lib/iar/nrf52840/: nrf_radio_driver.a
    ../../../../../../../../external/zboss/zb_error/: zb_error_to_string.c
    ../../../../../../../../external/zboss/osif/: zb_nrf52_common.c zb_nrf52_nrf_logger.c zb_nrf52_nvram.c zb_nrf52_sdk_config_deps.c zb_nrf52_timer.c zb_nrf52_transceiver.c
    ../../../../../../../../external/zboss/addons/zcl/: zb_zcl_common_addons.c zb_zcl_ota_upgrade_addons.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_util_platform.c nrf_assert.c
    ../../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../../components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../../../../../../../../components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../../../../../../../../components/libraries/assert/: assert.c
    ../../../../../../../../external/fnmatch/: fnmatch.c
    ../../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../../components/libraries/cli/: nrf_cli.c
    ../../../../../../../../components/libraries/cli/cdc_acm/: nrf_cli_cdc_acm.c
    ../../../../../../../../components/libraries/cli/rtt/: nrf_cli_rtt.c
    ../../../../../../../../components/libraries/cli/uart/: nrf_cli_uart.c
    ../../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_rng.c nrf_drv_uart.c
    ../../../../../../../../modules/nrfx/hal/: nrf_ecb.c nrf_nvmc.c
    ../../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_rng.c nrfx_systick.c nrfx_timer.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c
    ../../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group Board Support
    ../../../../../../../../components/libraries/bsp/: bsp.c
  group Application
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group None
    ../../../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
    ../../../: main.c
  group nRF_Zigbee
    ../../../../../../../../components/zigbee/cli/: zigbee_cli.c zigbee_cli_cmd.c zigbee_cli_cmd_attr.c zigbee_cli_cmd_attr_report.c zigbee_cli_cmd_bdb.c zigbee_cli_cmd_generic_cmd.c zigbee_cli_cmd_ping.c zigbee_cli_cmd_radio.c zigbee_cli_cmd_zcl.c zigbee_cli_cmd_zdo.c zigbee_cli_utils.c
    ../../../../../../../../components/zigbee/common/: zigbee_helpers.c zigbee_logger_eprxzcl.c
  group UTF8/UTF16 converter
    ../../../../../../../../external/utf_converter/: utf.c
